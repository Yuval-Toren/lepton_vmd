<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\new_lepton_Contrast_VMD.ewp</path>
  </project>
  <batchBuild/>
</workspace>